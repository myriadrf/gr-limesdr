options:
  parameters:
    author: Lime Microsystems
    category: Custom
    generate_options: qt_gui
    id: top_block
    output_language: python
    run_options: run
    title: FM transmitter
  states: {}

blocks:
- name: analog_nbfm_tx_0_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: '48000'
    fh: '-1.0'
    max_dev: 2e3
    quad_rate: '480000'
    tau: '75e-6'
  states: {}
- name: blocks_wavfile_source_0_0
  id: blocks_wavfile_source
  parameters:
    file: /home/garmus/GITHUB/gr-limesdr/examples/guitar.wav
    repeat: 'True'
  states: {}
- name: limesdr_sink_0
  id: limesdr_sink
  parameters:
    allow_tcxo_dac: '0'
    calibr_bandw_ch0: '0'
    calibr_bandw_ch1: '0'
    channel_mode: '0'
    dacVal: '125'
    digital_bandw_ch0: 100e3
    digital_bandw_ch1: 100e3
    gain_dB_ch0: '60'
    gain_dB_ch1: '60'
    oversample: '0'
    pa_path_ch1: '1'
    rf_freq: 446.09375e6
    samp_rate: 2e6
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: 2e6
    fc: 446.09375e6
    fftsize: '1024'
    name: '"Transmitting data"'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '6'
    interp: '25'
    taps: ''
    type: ccf
  states: {}

connections:
- [analog_nbfm_tx_0_0, '0', rational_resampler_xxx_0, '0']
- [blocks_wavfile_source_0_0, '0', analog_nbfm_tx_0_0, '0']
- [rational_resampler_xxx_0, '0', limesdr_sink_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-207-gcaa7e7f1
