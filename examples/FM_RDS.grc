options:
  parameters:
    author: Lime Microsystems
    category: Custom
    generate_options: qt_gui
    id: rds_rx
    output_language: python
    title: FM RDS receiver
  states: {}

blocks:
- name: audio_decim
  id: variable
  parameters:
    value: '5'
  states: {}
- name: audio_decim_rate
  id: variable
  parameters:
    value: int(baseband_rate/audio_decim)
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: baseband_rate
  id: variable
  parameters:
    value: samp_rate/bb_decim
  states: {}
- name: bb_decim
  id: variable
  parameters:
    value: '4'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    label: Frequency
    outputmsgname: value
    showports: 'False'
    start: 88e6
    step: '1000'
    stop: 108e6
    value: 100.1e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: RF Gain
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '70'
    stop: '70'
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: Volume
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '51'
    stop: '2'
    value: '0.5'
  states: {}
- name: xlate_bandwidth
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: analog_fm_deemph_0_0
  id: analog_fm_deemph
  parameters:
    samp_rate: audio_decim_rate
    tau: '75e-6'
  states: {}
- name: analog_fm_deemph_0_0_0
  id: analog_fm_deemph
  parameters:
    samp_rate: audio_decim_rate
    tau: '75e-6'
  states: {}
- name: analog_pll_refout_cc_0
  id: analog_pll_refout_cc
  parameters:
    max_freq: 2 * math.pi * (19000+200) / baseband_rate
    min_freq: 2 * math.pi * (19000-200) / baseband_rate
    w: '0.001'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: bb_decim
    deemph_tau: '75e-6'
    quad_rate: samp_rate
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: audio_rate
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_imag_0
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: '2'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    comment: Clock Recovery MM + Costas Loop = mpsk reciever
    gain_mu: '0.050'
    gain_omega: '0.001'
    mu: '0.5'
    omega: 21.0526*(1+0.0)
    omega_relative_limit: '0.005'
    type: complex
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: '0.0314159'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: fir_filter_xxx_1
  id: fir_filter_xxx
  parameters:
    decim: audio_decim
    taps: firdes.low_pass(1.0,baseband_rate,13e3,3e3,window.WIN_HAMMING)
    type: fff
  states: {}
- name: fir_filter_xxx_2
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: firdes.complex_band_pass(1.0,baseband_rate,19e3-500,19e3+500,1e3,window.WIN_HAMMING)
    type: fcc
  states: {}
- name: fir_filter_xxx_3
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: firdes.band_pass(1.0,baseband_rate,38e3-13e3,38e3+13e3,3e3,window.WIN_HAMMING)
    type: fff
  states: {}
- name: fir_filter_xxx_5
  id: fir_filter_xxx
  parameters:
    decim: audio_decim
    taps: firdes.low_pass(1.0,baseband_rate,20e3,40e3,window.WIN_HAMMING)
    type: fff
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, xlate_bandwidth, 100000)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 57e3
    decim: audio_decim
    samp_rate: baseband_rate
    taps: firdes.low_pass(2500.0,baseband_rate,2.4e3,2e3,window.WIN_HAMMING)
    type: fcc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: limesdr_source_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    channel_mode: '0'
    dacVal: '125'
    digital_bandw_ch0: 100e3
    digital_bandw_ch1: 100e3
    gain_dB_ch0: gain
    gain_dB_ch1: gain
    lna_path_ch0: '3'
    lna_path_ch1: '3'
    oversample: '0'
    rf_freq: freq
    samp_rate: samp_rate
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      L+R for
      stereo
      receivers
    note: L+R
  states: {}
- name: note_0_0
  id: note
  parameters:
    comment: |-
      In FM stereo broadcasting, 
      a pilot tone of 19 kHz indicates 
      that there is stereophonic 
      information at 38 kHz 
      (19×2, the second harmonic of the pilot). 
      The receiver doubles the frequency 
      of the pilot tone and uses it as a 
      frequency and phase reference to 
      demodulate the stereo information.
    note: Pilot
  states: {}
- name: note_0_0_0
  id: note
  parameters:
    comment: |-
      DSBSC modulation
      of 38 kHz sinewave
      for mono
    note: DSBSC
  states: {}
- name: note_0_1
  id: note
  parameters:
    comment: |-
      L-R for
      mono
      receivers
    note: L-R
  states: {}
- name: note_0_2
  id: note
  parameters:
    comment: |-
      Digital signal which 
      includes information such 
      as the name of the station, 
      or free text such as the title 
      of the program or the music.
    note: RDS
  states: {}
- name: note_10
  id: note
  parameters:
    comment: |-
      We use lowest possible
      analog filter bandwidth
      and 
      100 kHz digital filter bandwidth
    note: LimeSDR
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_2
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: qtgui_freq_sink_x_3
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: '2375'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
    ylabel: Scope Plot
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: baseband_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    ylabel: Pilot
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '512'
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: audio_decim_rate
    interp: audio_rate
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: audio_decim_rate
    interp: audio_rate
    type: fff
  states: {}
- name: rds_decoder_0
  id: rds_decoder
  parameters: {}
  states: {}
- name: rds_panel_0
  id: rds_panel
  parameters: {}
  states: {}
- name: rds_parser_0
  id: rds_parser
  parameters:
    pty_locale: '0'
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '1'
    decim: '1'
    gain: '1'
    ntaps: '100'
    samp_rate: samp_rate/bb_decim/audio_decim
    sym_rate: '2375'
    type: fir_filter_ccf
  states: {}

connections:
- [analog_fm_deemph_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [analog_fm_deemph_0_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_pll_refout_cc_0, '0', blocks_multiply_xx_1, '0']
- [analog_pll_refout_cc_0, '0', blocks_multiply_xx_1, '1']
- [analog_wfm_rcv_0, '0', fir_filter_xxx_1, '0']
- [analog_wfm_rcv_0, '0', fir_filter_xxx_2, '0']
- [analog_wfm_rcv_0, '0', fir_filter_xxx_3, '0']
- [analog_wfm_rcv_0, '0', freq_xlating_fir_filter_xxx_1, '0']
- [analog_wfm_rcv_0, '0', qtgui_freq_sink_x_2, '0']
- [analog_wfm_rcv_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_add_xx_0, '0', analog_fm_deemph_0_0_0, '0']
- [blocks_complex_to_imag_0, '0', blocks_multiply_xx_0, '1']
- [blocks_complex_to_imag_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_complex_to_real_0, '0', digital_binary_slicer_fb_0, '0']
- [blocks_keep_one_in_n_0, '0', digital_diff_decoder_bb_0, '0']
- [blocks_multiply_const_vxx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', rational_resampler_xxx_0_0, '0']
- [blocks_multiply_xx_0, '0', fir_filter_xxx_5, '0']
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_multiply_xx_1, '0', blocks_complex_to_imag_0, '0']
- [blocks_sub_xx_0, '0', analog_fm_deemph_0_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_keep_one_in_n_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', blocks_complex_to_real_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', qtgui_time_sink_x_0, '0']
- [digital_costas_loop_cc_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [digital_diff_decoder_bb_0, '0', rds_decoder_0, '0']
- [fir_filter_xxx_1, '0', blocks_add_xx_0, '0']
- [fir_filter_xxx_1, '0', blocks_sub_xx_0, '0']
- [fir_filter_xxx_1, '0', qtgui_freq_sink_x_0, '0']
- [fir_filter_xxx_2, '0', analog_pll_refout_cc_0, '0']
- [fir_filter_xxx_3, '0', blocks_multiply_xx_0, '0']
- [fir_filter_xxx_3, '0', qtgui_freq_sink_x_3, '0']
- [fir_filter_xxx_5, '0', blocks_add_xx_0, '1']
- [fir_filter_xxx_5, '0', blocks_sub_xx_0, '1']
- [freq_xlating_fir_filter_xxx_0, '0', analog_wfm_rcv_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_1, '0']
- [freq_xlating_fir_filter_xxx_1, '0', qtgui_freq_sink_x_0_1, '0']
- [freq_xlating_fir_filter_xxx_1, '0', root_raised_cosine_filter_0, '0']
- [limesdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']
- [rational_resampler_xxx_0_0, '0', audio_sink_0, '1']
- [rds_decoder_0, out, rds_parser_0, in]
- [rds_parser_0, out, rds_panel_0, in]
- [root_raised_cosine_filter_0, '0', digital_costas_loop_cc_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-207-gcaa7e7f1
