options:
  parameters:
    author: Lime Microsystems
    category: Custom
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: Signal analyzer
  states: {}

blocks:
- name: analog_filter_bandwidth_rx
  id: variable_qtgui_entry
  parameters:
    gui_hint: 2,0,1,1
    label: RX analog filter bandwidth [MHz]
    type: real
    value: '10'
  states: {}
- name: baseband_rx
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,1,1,1
    label: RX baseband [MHz]
    type: real
    value: '600'
  states: {}
- name: digital_filter_bandwidth_rx
  id: variable_qtgui_entry
  parameters:
    gui_hint: 2,1,1,1
    label: RX digital filter bandwidth [MHz]
    type: real
    value: sample_rate/2e6
  states: {}
- name: gain_rx
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: RX gain
    rangeType: int
    start: '0'
    step: '1'
    stop: '70'
    value: '0'
  states: {}
- name: nco_freq_rx
  id: variable_qtgui_entry
  parameters:
    gui_hint: 1,1,1,1
    label: RX NCO [MHz]
    type: real
    value: '0'
  states: {}
- name: rfe_attenuation
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 3,1,1,1
    label: RFE Attenuation [dB]
    labels: '[''0'', ''2'', ''4'', ''6'', ''8'', ''10'', ''12'', ''14'']'
    num_opts: '0'
    options: '[0, 1, 2, 3, 4, 5 ,6 , 7]'
    type: int
    value: '0'
  states: {}
- name: rfe_mode
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 3,0,1,1
    label: LimeRFE Mode
    label0: RX
    label1: NONE
    label2: TXRX
    num_opts: '3'
    option0: '0'
    option1: '2'
    option2: '3'
    type: int
    value: '0'
  states: {}
- name: rfe_notch
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 4,0,1,1
    label: AM/FM Notch Filter
    label0: Enabled
    label1: Disabled
    num_opts: '2'
    option0: '1'
    option1: '0'
    type: int
    value: '1'
  states: {}
- name: sample_rate
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,0,1,1
    label: Sample rate [S/s]
    type: raw
    value: 5e6
  states: {}
- name: limesdr_rfe_0
  id: limesdr_rfe
  parameters:
    atten: rfe_attenuation
    comm_type: '1'
    mode: rfe_mode
    notch: rfe_notch
    rx_channel: '-2'
    rx_port: '1'
    tx_channel: '-2'
    tx_port: '2'
  states: {}
- name: limesdr_source_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    analog_bandw_ch0: analog_filter_bandwidth_rx*1e6
    analog_bandw_ch1: '0'
    calibr_bandw_ch0: sample_rate
    calibr_bandw_ch1: '0'
    ch_align: 'False'
    channel_mode: '0'
    dacVal: '125'
    digital_bandw_ch0: digital_filter_bandwidth_rx*1e6
    digital_bandw_ch1: '0'
    gain_dB_ch0: gain_rx
    gain_dB_ch1: '0'
    nco_freq_ch0: nco_freq_rx*1e6
    oversample: '0'
    rf_freq: baseband_rx*1e6
    samp_rate: sample_rate
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: sample_rate
    fc: baseband_rx*1e6
    fftsize: '4096'
    gui_hint: 5,0,1,2
    name: ''
    showports: 'True'
    showrf: 'True'
    type: complex
  states: {}

connections:
- [limesdr_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.9.8.0
