options:
  parameters:
    author: Lime Microsystems
    category: Custom
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: GFSK loopback
  states: {}

blocks:
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: analog_quadrature_demod_cf_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    repeat: 'True'
    type: byte
  states: {}
- name: digital_gfsk_demod_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '4'
    sensitivity: '1'
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.35'
    samples_per_symbol: '4'
    sensitivity: '1'
    verbose: 'True'
  states: {}
- name: digital_packet_headergenerator_bb_0
  id: digital_packet_headergenerator_bb
  parameters:
    len_tag_key: '"packet_len"'
  states: {}
- name: digital_packet_headerparser_b_0
  id: digital_packet_headerparser_b
  parameters: {}
  states: {}
- name: limesdr_sink_0
  id: limesdr_sink
  parameters:
    allow_tcxo_dac: '0'
    analog_bandw_ch0: 10e6
    analog_bandw_ch1: 10e6
    calibr_bandw_ch0: '0'
    calibr_bandw_ch1: '0'
    channel_mode: '0'
    dacVal: '125'
    digital_bandw_ch0: '0'
    digital_bandw_ch1: '0'
    gain_dB_ch0: '40'
    gain_dB_ch1: '40'
    oversample: '0'
    pa_path_ch1: '1'
    rf_freq: 1e9
    samp_rate: 0.5e6
  states: {}
- name: limesdr_source_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    analog_bandw_ch0: 10e6
    analog_bandw_ch1: 10e6
    calibr_bandw_ch0: '0'
    calibr_bandw_ch1: '0'
    channel_mode: '0'
    dacVal: '125'
    digital_bandw_ch0: '0'
    digital_bandw_ch1: '0'
    gain_dB_ch0: '40'
    gain_dB_ch1: '40'
    lna_path_ch1: '1'
    oversample: '0'
    rf_freq: 1e9
    samp_rate: 0.5e6
  states: {}
- name: pdu_pdu_to_stream_x_0
  id: pdu_pdu_to_stream_x
  parameters:
    early_behavior: pdu.EARLY_BURST_APPEND
    type: byte
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    name: Sent Signal
    size: '1024'
    srate: 2.4e6
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    name: Received Signal
    size: '1024'
    srate: 2.4e6
    type: float
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', qtgui_time_sink_x_0, '0']
- [analog_quadrature_demod_cf_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_file_source_0, '0', digital_packet_headergenerator_bb_0, '0']
- [digital_gfsk_demod_0, '0', digital_packet_headerparser_b_0, '0']
- [digital_gfsk_mod_0, '0', analog_quadrature_demod_cf_0, '0']
- [digital_gfsk_mod_0, '0', limesdr_sink_0, '0']
- [digital_packet_headergenerator_bb_0, '0', digital_gfsk_mod_0, '0']
- [digital_packet_headerparser_b_0, header_data, pdu_pdu_to_stream_x_0, pdus]
- [limesdr_source_0, '0', analog_quadrature_demod_cf_0_0, '0']
- [limesdr_source_0, '0', digital_gfsk_demod_0, '0']
- [pdu_pdu_to_stream_x_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-207-gcaa7e7f1
